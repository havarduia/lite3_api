Commit message: Added 3D View to the HMI.

File: urdf/lite3.urdf (robot description, URDF)
Before this commit: robot Lite3, 19 links, 18 joints
Links:
- link camera_link: geometry visual box size=0.025 0.09 0.025
